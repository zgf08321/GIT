# Keil uVision project project.uvproj, settings and files
target project (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: project +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\CMSIS;.\StdPeriphDriver\inc;.\Users\Inc;.\Device\ST5767;.\Device\Delay;.\Device\LCD12864;.\Device\key;.\Device\MENU;.\Device\DS18B20;.\Device\sys;.\Device\DS1302;.\Device\usart
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: system_stm32f10x.c core_cm3.c
  group StdPeriphDriver
    ./StdPeriphDriver/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c
  group StartUp
    ./StartUp/: startup_stm32f10x_md.s
  group User
    ./Users/Src/: stm32f10x_it.c main.c
    ./Device/Delay/: Delay.c
    ./Device/sys/: sys.c
    ./Device/usart/: usart.c
  group Device
    ./Device/ST5767/: ST5767.c
    ./Device/LCD12864/: LCD12864.c
    ./Device/key/: key.c
    ./Device/MENU/: MENU.c
    ./Device/DS18B20/: DS18B20.c
    ./Device/DS1302/: DS1302.c
